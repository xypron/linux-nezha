## drivers/xrp/Kconfig
```kconfig
config XRP
        tristate  "XRP support"
        #select SET_FS	
	default m
	help
          This module provides the function of vp6 device.
```
